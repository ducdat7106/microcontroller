# Keil uVision project time_mode_of_timer0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: time_mode_of_timer0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\User
  group Main
    ./Main/: main.c var.h
  group User
    ./User/: time_timer0.c
