# Keil uVision project counter_timer0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: counter_timer0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\Lib
  group Main
    ./Main/: main.c var.h
  group User
    ./Lib/: counter_timer0.c
