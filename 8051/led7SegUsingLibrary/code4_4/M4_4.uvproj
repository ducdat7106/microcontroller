# Keil uVision project M4_4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: M4_4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\Lib
  group Main
    ./Main/: var.h main.c
  group Lib
    ./Lib/: delay.c Led7Seg.c button.c timer0.c
