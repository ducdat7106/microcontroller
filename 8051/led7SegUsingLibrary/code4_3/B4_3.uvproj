# Keil uVision project B4_3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: B4_3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\Lib
  group Main
    ./Main/: main.c var.h
  group User
    ./Lib/: delay.c ledSingle.c led7Seg.c timer0.c button.c
