# Keil uVision project port_led_blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: port_led_blink +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\Lib
  group Main_My
    ./Main/: main.c var.h
  group Lib_My
    ./Lib/: delay.c blink.c
