# Keil uVision project ic_buffer_controll_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ic_buffer_controll_led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Objects/: ic_buffer_controll_led.c
